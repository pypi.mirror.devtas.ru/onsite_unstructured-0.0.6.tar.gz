simulink model "model_ref"  (R2024a)
settings: Solver=ode4  StartTime=0.0  StopTime=10  FixedStep=0.0001  RelTol=1e-3
model workspace (MAT data in the model file):
  Brake_MC_D = 3.3
  CarSimTCKMAP = [0.006425 0.006425 0.006425 0.006425 0.006424 0.006419 0.006386 0.006243 0.005735 0.004185 0.002578 0.000614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]
  CarSimTCLambdaPMAP = [1.864 1.78 1.701 1.608 1.56 1.519 1.464 1.412 1.356 1.309 1.259 1.203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]
  CarSimTCiMAP1 = [0 0.1 0.2 0.3 0.4 0.5 0.6 0.7 0.8 0.9 0.95 0.99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]
  CarSimTCiMAP2 = [0 0.102 0.202 0.306 0.353 0.4 0.452 0.502 0.551 0.6 0.65 0.7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]
  DOWN_Data_lookup = [0 0 0 0 0 0 0 0 0 0 0 0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]
  DOWN_Gear_lookup = [1 2 3 4 5]
  DOWN_Throttle_lookup = [0 1 2 3 4 5 6 7 8 9 10 11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]
  Diff_gear_ratio = 4.1
  MC_lever_ratio = 0.02381
  UP_Data_lookup = [13.2140963951 13.2140963951 13.2140963951 13.2140963951 13.2140963951 13.2140963951 13.6741047457 14.0455395451 14.3574336302 14.6810803701 15.0507893957 16.3806466373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]
  UP_Gear_lookup = [1 2 3 4 5]
  UP_Throttle_lookup = [0 1 2 3 4 5 6 7 8 9 10 11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]
  eng_One_Order_T = 0.005
  eng_T = [0 0 0 0 0 0 0 0 0 0 15 64.064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]
  eng_Ted = 0.005
  eng_n = [0 86.6667 173.333 433.333 750 866.667 1300 1733.33 2166.67 2600 3033.33 3466.67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]
  eng_throttle = [0 0.1 0.15 0.2 0.35 0.5 0.7 0.85 0.95 1]
  rotational_inertia_of_crankshaft = 0.16
values from neighbouring files (symbols this model uses):
  v0 = 0    [init.m]    (also in tempScript.m = 3)
  x0 = -27.92254    [init.m]    (also in tempScript.m = 66.5)
  y0 = 292.5054    [init.m]    (also in tempScript.m = 257.9)
  yaw = 0    [init.m]    (also in tempScript.m = -1.125)
undefined symbols (not defined in the file or in its folder): a_brake, a_thr, brake_table, thr_table
(part 2 of 2)

== matlab function model_ref/车辆动力学模型/车轮系统/轮胎RR ==
function [FX0,FY0,MZ0,MY]=MagicTire(FZ,KAPPA,ALPHA,VS)
% The Magic tire model fcn

% INPUT 1 : VERTICAL LOAD FORCE --- FZ
% INPUT 2 : TIRE SIDESLIP ANGLE --- ALPHA
% INPUT 3 : TIRE LONGITUDINAL SLIP RATIO --- KAPPA
% INPUT 4 : TIRE CONTACT CENTER VELOCITY --- VS
% INPUT 5 : TIRE CAMBER ---GAMMA
GAMMA=0;
ALPHA=-ALPHA;           % 根据侧倾角定义
%% TIRE DATA
R0 = 0.344; % TIRE RADIUS (M)
Re = 0.314;   % EFFECTIVE RADIUS (M)
V0 = 16.6;  % REFERENCE VELOCITY 60 (KM/H)
FZ0 = 4850; % UNLOAD NOMINAL FORCE (N)

%% SCALIING FACTORS LAMDA
%* PURE SLIP
LFZ0 = 1; % NOMINAL LOAD
LMUX = 1; % PEAK FRICTION COEFFICENT LONGITUDINAL
LMUY = 1; % PEAK FRICTION COEFFICENT LATERAL
LMUV = 1; % SLIP DECAYING FRICTION
LKX = 1;  % BRAKE SLIP STIFFNESS
LKY = 1;  % CORNERING STIFFNESS
LCX = 1;  % SHAPE FACTOR
LCY = 1;  % SHAPE FACTOR
LEX = 1;  % CURVATURE FACTOR
LEY = 1;  % CURVATURE FACTOR
LHX = 0;  % HORIZONTAL FACTOR
LHY = 0;  % HORIZONTAL FACTOR
LVX = 0;  % VERTICAL FACTOR
LVY = 0;  % 
LGAY = 1; % CAMBER FORCE STIFFNESS
LGAZ = 0; % CAMBER TORQUE STIFFNESS
LT = 1;   % PNEUMATIC TRAIL
LMR = 0;  % RESIDUAL TORQUE (LRES IN EXCEL)

%* COMBINED SLIP
LXAL = 0; % ALPHA INFLUENCE ON Fx
LYKA = 0; % KAPPA INFLUENCE ON Fy
LVYKA = 0;% KAPPA INDUCED PLYSTEER
LS = 0;   % MOMENT ARM OF Mz 

%* OTHER
LCZ = 1; % RADIAL TIRE STIFFNESS
LMX = 0; % OVERTURNING COUPLE STIFFNESS
LMY = 1; % ROLLING RESISTANCE MOMENT

%% NON-DIMENSIONAL PARAMETERS P Q S R 
%* P FOR FX
PCX1 = 1.6411;  
PCX2 = 1;
PDX1 = 1.1739;
PDX2 = -0.16395;
PEX1 = 0.46403;
PEX2 = 0.25022;
PEX3 = 0.067842;
PEX4 = -3.7604*10^(-5);
PKX1 = 22.303;
PKX2 = 0.48896;
PKX3 = 0.21253;
PHX1 = 0.0012297;
PHX2 = 0.0004318;
PVX1 = -8.8098*10^(-6);
PVX2 = 1.862*10^(-5);
%* P FOR FY
PCY1 = 1.3507;
PDY1 = 1.0489;
PDY2 = -0.18033;
PDY3 = -2.8821;
PEY1 = -0.0074722;
PEY2 = -0.0063208;
PEY3 = -9.9935;
PEY4 = -760.14;
PKY1 = -21.92;
PKY2 = 2.0012;
PKY3 = -0.024778;
PHY1 = 0.0026747;
PHY2 = 8.9094*10^(-5);
PHY3 = 0.031415;
PVY1 = 0.037318;
PVY2 = -0.010049;
PVY3 = -0.32931;
PVY4 = -0.69553;
%* Q FOR MZ
QHZ1 = 0.0047326;
QHZ2 = 0.0026687;
QHZ3 = 0.11998;
QHZ4 = 0.059083;
QBZ1 = 10.904;
QBZ2 = -1.8412;
QBZ3 = -0.52041;
QBZ4 = 0.039211;
QBZ5 = 0.41511;
QCZ1 = 1.2136;
QDZ1 = 0.093509;
QDZ2 = -0.0092183;
QDZ3 = -0.057061;
QDZ4 = 0.73954;
QEZ1 = -1.5697;
QEZ2 = 0.33394;
QEZ3 = 0;
QEZ4 = 0.26711;
QEZ5 = -3.594;
QBZ10 = 0;
QDZ6 = -0.0067783;
QDZ7 = 0.0052254;
QDZ8 = -0.18175;
QDZ9 = 0.029952;
%* Q for My rolling ressistance moment
QSY1 = 0.1;
QSY2 = 0;

%* COMBINED SLIP 
% R FOR FX
RBX1 = 13.276;
RBX2 = -13.778;
RCX1 = 1.2568;
REX1 = 0.65225;
REX2 = -0.24948;
RHX1 = 0.0050722;
% R FOR FY
RBY1 = 7.1433;
RBY2 = 9.1916;
RBY3 = -0.027856;
RCY1 = 1.0719;
REY1 = -0.27572;
REY2 = 0.32802;
RHY1 = 5.7448*10^(-6);
RHY2 = -3.1368*10^(-5);
RVY1 = -0.027825;
RVY2 = 0.053604;
RVY3 = -0.27568;
RVY4 = 12.12;
RVY5 = 1.9;
RVY6 = -10.704;
% S FOR MZ
SSZ1 = 0.033372;
SSZ2 = 0;
SSZ3 = 0.56742;
SSZ4 = -0.24116;

%* SCALING VERTICAL LOAD Fz0' CHANGE dfz
dfz = (FZ-LFZ0*FZ0)./(LFZ0*FZ0);
%% LONGITUDINAL FORCE (PURE)
% FX0 = DX*SIN(CX*ATAN(BX*KX-EX*(BX*KX-ATAN(BX*KX))))+SVX
SHX = (PHX1+PHX2*dfz)*LHX;
KX = KAPPA+SHX;
CX = PCX1*LCX;
MUX = (PDX1+PDX2*dfz)*LMUX/(1+LMUV*VS/V0);
DX = MUX*FZ*1;
EX = (PEX1+PEX2*dfz+PEX3*dfz^2)*(1-PEX4*sign(KAPPA))*LEX;
KXKA = FZ*(PKX1+PKX2*dfz)*exp(PKX3*dfz)*LKX;
BX = KXKA/(CX*DX+0.1);
SVX = FZ*(PVX1+PVX2*dfz)*LVX*LMUX*1;
FX0 = DX*sin(CX*atan(BX*KX-EX*(BX*KX-atan(BX*KX))))+SVX;

%% LATERAL FORCE (PURE)
% FY0 = DY*sin(CY*atan(BY*ALY-EY*(BY*ALY-atan(BY*ALY))))+SVY
SHY = (PHY1+PHY2*dfz)*LHY+PHY3*sin(GAMMA)*LGAY*1+1-1;
ALY = ALPHA*sign(VS)+SHY; 
CY = PCY1*LCY;
MUY = (PDY1+PDY2*dfz)*(1-PDY3*sin(GAMMA)^2)*LMUY/(1+LMUV*VS/V0);
DY = MUY*FZ*1;
EY = (PEY1+PEY2*dfz)*(1-(PEY3+PEY4*sin(GAMMA))*sign(ALY))*LEY;
KYAL0 = PKY1*LFZ0*FZ0*sin(2*atan(FZ/(PKY2*LFZ0*FZ0)))*LKY;
KYAL = KYAL0*(1-PKY3*sin(GAMMA)^2)*1;
BY = KYAL/(CY*DY+0.1);
SVY = FZ*((PVY1+PVY2*dfz)*LVY+(PVY3+PVY4*dfz)*sin(GAMMA)*LGAY)*LMUY*1;
FY0 = DY*sin(CY*atan(BY*ALY-EY*(BY*ALY-atan(BY*ALY))))+SVY;

%% ALIGNING TORQUE (PURE)
% MZ0 = MZP+MZR0;
SHT =  QHZ1+QHZ2*dfz+(QHZ3+QHZ4*dfz)*sin(GAMMA);
ALT =  ALPHA*sign(VS)+SHT;
BT = (QBZ1+QBZ2*dfz+QBZ3*dfz^2)*(1+QBZ4*sin(GAMMA)+QBZ5*abs(sin(GAMMA)))*LKY/LMUY;
CT = QCZ1;
DT0 = FZ*(R0/(LFZ0*FZ0))*(QDZ1+QDZ2*dfz)*LT*sign(VS);
DT = DT0*(1+QDZ3*sin(GAMMA)+QDZ4*sin(GAMMA)^2)*1;
ET = (QEZ1+QEZ2*dfz+QEZ3*dfz^2)*(1+(QEZ4+QEZ5*sin(GAMMA))*2/pi*atan(BT*CT*ALT));
T0 = DT*cos(CT*atan(BT*ALT-ET*(BT*ALT-atan(BT*ALT))))*(cos(ALPHA));
MZP = -T0*FY0;

SHF = SHY+SVY/(KYAL+0.1);
ALR = ALPHA*sign(VS)+SHF;
BR = QBZ10*BY*CY;
CR = 1;
DR = FZ*R0*((QDZ6+QDZ7*dfz)*LMR*1+(QDZ8+QDZ9*dfz)*sin(GAMMA)*LGAZ*1)*(cos(ALPHA))*LMUY*sign(VS)+1-1;
MZR0 = DR*cos(CR*atan(BR*ALR));

MZ0 = MZP+MZR0;

%% LONGITUDINAL FORCE COMBINED SLIP
SHXAL = RHX1;
EXAL = REX1+REX2*dfz;
CXAL = RCX1;
BXAL = RBX1*cos(atan(RBX2*KAPPA))*LXAL;
ALS = ALPHA*sign(VS)+SHXAL;
GXAL0 = cos(CXAL*atan(BXAL*SHXAL-EXAL*(BXAL*SHXAL-atan(BXAL*SHXAL))));
GXAL = cos(CXAL*atan(BXAL*ALS-EXAL*(BXAL*ALS-atan(BXAL*ALS))))/(GXAL0);
FX = GXAL*FX0;

%% LATERAL FORCE COMBINED SLIP
DVYK = MUY*FZ*(RVY1+RVY2*dfz+RVY3*sin(GAMMA))*cos(atan(RVY4*ALPHA*sign(VS)))*1;
SVYK = DVYK*sin(RVY5*atan(RVY6*KAPPA));
SHYK = RHY1+RHY2*dfz;
EYK = REY1+REY2*dfz;
CYK = RCY1;
BYK = RBY1*cos(atan(RBY2*(ALPHA*sign(VS)-RBY3)))*LYKA;
KS = KAPPA+SHYK;
GYK0 = cos(CYK*atan(BYK*SHYK-EYK*(BYK*SHYK-atan(BYK*SHYK))));
GYK = cos(CYK*atan(BYK*KS-EYK*(BYK*KS-atan(BYK*KS))))./(GYK0);
FY = GYK*FY0+SVYK;

%% ALIGNING TORQUE COMBINED SLIP
AREQ = sqrt(ALR^2+(KXKA/(KYAL+0.1))^2*KAPPA^2)*sign(ALR);
ATEQ = sqrt(ALT^2+(KXKA/(KYAL+0.1))^2*KAPPA^2)*sign(ALT);
S = R0*(SSZ1+SSZ2*(FY/(FZ0*LFZ0))+(SSZ3+SSZ4*dfz)*sin(GAMMA))*LS;
MZR = DR*cos(CR*atan(BR*AREQ));
FYP = FY-SVYK;
T = DT*cos(CT*atan(BT*ALT-ET*(BT*ATEQ-atan(BT*ATEQ))))*(cos(ALPHA));
MZP = -T*FYP;
MZ = MZP+MZR+S*FX;

%% ROLLING RESSISTANCE MOMENT MY
MY = -FZ*R0*(QSY1*atan(VS*(1-abs(KAPPA))/V0)+QSY2*FX/(LFZ0*FZ0))*LMY;

% y=[FX0,FY0,MZ0,MY]';

== matlab function model_ref/Brake System/制动转矩 ==
function y = fcn_B_tor(Br_Con,Tor_Br,Tor_Dr,dx)
  
%% 输入
% 车辆速度
v_x=dx;

%%
if Br_Con==0
    Tor_B=Tor_Br;
else
    if v_x==0
       Tor_B=-Tor_Dr;
    else
       if v_x>0
          Tor_B=(-1)*Tor_Br;
       else
          Tor_B=Tor_Br;
       end
    end
end

y=Tor_B;

== matlab function model_ref/车辆动力学模型/Global_XYZ ==
function [ddX_G,ddY_G,ddZ_G]= Global_XYZ(road,droad,du,ddu, phi)

%% 输入
% 坡度和路肩
Slope=road(1);
%Shoulder=road(2);

% dSlope=droad(1);
% dShoulder=droad(2);

% XYZ坐标下速度
dX=du(1);
dY=du(2);

%XYZ坐标加速度
ddX=ddu(1);
ddY=ddu(2);
%

dda = sqrt(ddX*ddX + ddY*ddY);
dda_G = cos(Slope)*dda;
ddZ_G = -sin(Slope)*dda;
ddX_G = dda_G * cos(phi);
ddY_G = dda_G * sin(phi);

%% 
%ddX_G=-sin(Slope)*dSlope*dX+cos(Slope)*ddX;
%ddZ_G=-cos(Slope)*dSlope*dX-sin(Slope)*ddX;

== matlab function model_ref/MATLAB Function1 ==
function [Dr_C,Br_C,gear]= Control_DB(gear,v_x,thrs,bra)

gear_i=gear;
%%
gear=gear_i;
Dr_C=thrs;
if bra<0
    bra = 0;
end
Br_C=bra;
end

== matlab function model_ref/驱动系统/发动机模型/Engine/MATLAB Function ==
function y = TwoDLookupFcn(u1,u2,TbVal,Row,Col)
%* here using the matlab function 'interp2 ' to get the value of the point
% the syntax: Vq = interp2(BreakPoints1,BreakPoints2,TablePoints,Row,Col,method)
y = interp2(Col,Row,TbVal,u2,u1,'linear');

== matlab function model_ref/驱动系统/发动机模型/Planetary Gear/shift_ratio ==
function ratio = fcn(u,TbVal,Brkdots)
val = interp1(Brkdots,TbVal,u,'nearest');
ratio = val;

== matlab function model_ref/驱动系统/发动机模型/Torque Converter/MATLAB Function1 ==
function y = fcn(u,TbVal,Brkdots)
val = interp1(Brkdots,TbVal,u,'linear','extrap');
y = val;

== matlab function model_ref/驱动系统/发动机模型/Torque Converter/MATLAB Function2 ==
function y = fcn(u,TbVal,Brkdots)
y = interp1(Brkdots,TbVal,u,'linear','extrap');

== matlab function model_ref/驱动系统/发动机模型/升降档位/MATLAB Function1 ==
function Gear = gearShift(v,up_th,down_th)
    persistent currState delay_time;
    if(isempty(currState))
        currState=0; %0为保持状态，-1为将挡状态，1为升挡状态
        delay_time=0;
    end
    upOrDown = 0;
    switch(currState)
        case 0
            if(v<down_th)
                currState=-1;
            elseif(v>up_th)
                 currState=1;
            end
        case -1
            delay_time = delay_time+1;
            if(v>down_th)
                currState=0;
                delay_time=0;
            elseif(v<=down_th && delay_time>=2)
                 currState=0;
                 upOrDown = -1;
                 delay_time=0;
            end
        case 1
            delay_time = delay_time+1;
            if(v<up_th)
                currState=0;
                delay_time=0;
            elseif(v>=up_th && delay_time>=2)
                 currState=0;
                 upOrDown = 1;
                 delay_time=0;
            end
    end
    
    persistent currGear;
    if(isempty(currGear))
        currGear=1;
    end
    switch(currGear)
        case 1
            if(upOrDown==1)
                currGear=2;      
            end
        case 2
            if(upOrDown==1)
                currGear=3;
            elseif(upOrDown==-1)
                currGear=1;     
            end
        case 3
            if(upOrDown==1)
                currGear=4;
            elseif(upOrDown==-1)
                currGear=2;     
            end
        case 4
            if(upOrDown==1)
                currGear=5;
            elseif(upOrDown==-1)
                currGear=3;     
            end
        case 5
            if(upOrDown==-1)
                currGear=4;    
            end
    end

Gear=currGear;

== matlab function model_ref/驱动系统/发动机模型/升降档位/Subsystem1/MATLAB Function ==
function y = TwoDLookupFcn(u1,u2,TbVal,Row,Col)
%* here using the matlab function 'interp2 ' to get the value of the point
% the syntax: Vq = interp2(BreakPoints1,BreakPoints2,TablePoints,Row,Col,method)
y = interp2(Col,Row,TbVal,u2,u1,'linear');

== matlab function model_ref/驱动系统/发动机模型/升降档位/Subsystem1/MATLAB Function1 ==
function y = TwoDLookupFcn(u1,u2,TbVal,Row,Col)
%* here using the matlab function 'interp2 ' to get the value of the point
% the syntax: Vq = interp2(BreakPoints1,BreakPoints2,TablePoints,Row,Col,method)
y = interp2(Col,Row,TbVal,u2,u1,'linear');

== matlab function model_ref/车辆动力学模型/MATLAB Function ==
function [ddx,ddy,ddphi,ddAFL,ddAFR,ddARL,ddARR,ddX,ddY]=VDynamics(u,Tor_D,Tor_B,Fz,FwFL,FwFR,FwRL,FwRR,Steering,w_cg)

%% 车辆物理参数
g = 9.8;                % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）

TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
Iw_roll=0.9;            % 车轮滚动惯量

%% 车辆状态
% x=u(1);              % 纵向位移
% y=u(2);              % 横向位移
phi=u(1);            % 横摆角
% AngleFL=u(4);        % 左前车轮转动角度
% AngleFR=u(5);        % 右前车轮转动角度
% AngleRL=u(6);        % 左后车轮转动角度
% AngleRR=u(7);        % 右后车轮转动角度
% X=u(8);              % 全局坐标系下X轴方向位移
% Y=u(9);              % 全局坐标系下Y轴方向位移

dx=u(2);            % 纵向速度
dy=u(3);            % 侧向速度
dphi=u(4);          % 横摆角速度
% dAFL=u(5);          % 左前车轮转动角速度
% dAFR=u(6);          % 右前车轮转动角速度
% dARL=u(7);          % 左后车轮转动角速度
% dARR=u(8);          % 右后车轮转动角速度
% dX=u(17);            % 全局坐标系下X轴方向速度
% dY=u(18);            % 全局坐标系下Y轴方向速度

%% 转向系统
StFL=Steering(1);
StFR=Steering(2);
StRL=Steering(3);
StRR=Steering(4);

%% 驱动系统
TorFL_D=Tor_D(1);
TorFR_D=Tor_D(2);
TorRL_D=Tor_D(3);
TorRR_D=Tor_D(4);

%% 制动系统
TorFL_B=Tor_B(1);
TorFR_B=Tor_B(2);
TorRL_B=Tor_B(3);
TorRR_B=Tor_B(4);

% %% 道路
% Slope=road(1);          % 坡度
% Shoulder=road(2);       % 路肩

%% 车辆坐标
% xyz坐标系
cg_i=[0 0 hcg]';       %质心位置

PFL=[lf,TF/2,0]'; PFR=[lf,-TF/2,0]';    % 前轮接触点
PRL=[-lr,TR/2,0]'; PRR=[-lr,-TR/2,0]';  % 后轮接触点

%% 车辆受力
%车辆重力
% w_cg=G_Vehicle([Slope Shoulder]);
wG=zeros(6,1);
wG(1:3,1)=[w_cg(1) w_cg(2) w_cg(3)]';
wG(4:6,1)=cross(cg_i,wG(1:3,1));

% 车轮垂直载荷
% Fz=Vertical_Load(w_cg);
FzFL=Fz(1);
FzFR=Fz(2);
FzRL=Fz(3);
FzRR=Fz(4);

sFzFL=zeros(6,1);
sFzFL(1:3,1)=[0 0 1]';
sFzFL(4:6,1)=cross(PFL,sFzFL(1:3,1));

sFzFR=zeros(6,1);
sFzFR(1:3,1)=[0 0 1]';
sFzFR(4:6,1)=cross(PFR,sFzFR(1:3,1));

sFzRL=zeros(6,1);
sFzRL(1:3,1)=[0 0 1]';
sFzRL(4:6,1)=cross(PRL,sFzRL(1:3,1));

sFzRR=zeros(6,1);
sFzRR(1:3,1)=[0 0 1]';
sFzRR(4:6,1)=cross(PRR,sFzRR(1:3,1));

wFzFL=FzFL*sFzFL;
wFzFR=FzFR*sFzFR;
wFzRL=FzRL*sFzRL;
wFzRR=FzRR*sFzRR;

wFz=wFzFL+wFzFR+wFzRL+wFzRR;

% % 滑移率，侧偏角
% sigmaFL=Wheel_sys([StFL dAFL dx dy dphi 0]);
% sigmaFL_x=sigmaFL(1);
% alphaFL=sigmaFL(2);
% 
% sigmaFR=Wheel_sys([StFR dAFR dx dy dphi 0]);
% sigmaFR_x=sigmaFR(1);
% alphaFR=sigmaFR(2);
% 
% sigmaRL=Wheel_sys([StRL dARL dx dy dphi 1]);
% sigmaRL_x=sigmaRL(1);
% alphaRL=sigmaRL(2);
% 
% sigmaRR=Wheel_sys([StRR dARR dx dy dphi 1]);
% sigmaRR_x=sigmaRR(1);
% alphaRR=sigmaRR(2);

% 轮胎纵向、侧向、轮胎Z轴力矩、滚动阻力矩
% FwFL=MagicTire(FzFL,alphaFL,sigmaFL_x,dx);
FwFL_x=FwFL(1); 
FwFL_y=FwFL(2);
MwFL_z=FwFL(3); MwFL_y=FwFL(4);

% FwFR=MagicTire(FzFR,alphaFR,sigmaFR_x,dx);
FwFR_x=FwFR(1);
FwFR_y=FwFR(2);
MwFR_z=FwFR(3); MwFR_y=FwFR(4);

% FwRL=MagicTire(FzRL,alphaRL,sigmaRL_x,dx);
FwRL_x=FwRL(1); 
FwRL_y=FwRL(2);
MwRL_z=FwRL(3); MwRL_y=FwRL(4);

% FwRR=MagicTire(FzRR,alphaRR,sigmaRR_x,dx);
FwRR_x=FwRR(1); 
FwRR_y=FwRR(2);
MwRR_z=FwRR(3); MwRR_y=FwRR(4);

%轮胎纵向力
swFL_x=zeros(6,1);
swFL_x(1:3,1)=[cos(StFL) sin(StFL) 0]';
swFL_x(4:6,1)=cross(PFL,swFL_x(1:3,1));

swFR_x=zeros(6,1);
swFR_x(1:3,1)=[cos(StFR) sin(StFR) 0]';
swFR_x(4:6,1)=cross(PFR,swFR_x(1:3,1));

swRL_x=zeros(6,1);
swRL_x(1:3,1)=[cos(StRL) sin(StRL) 0]';
swRL_x(4:6,1)=cross(PRL,swRL_x(1:3,1));

swRR_x=zeros(6,1);
swRR_x(1:3,1)=[cos(StRR) sin(StRR) 0]';
swRR_x(4:6,1)=cross(PRR,swRR_x(1:3,1));

wFL_x=FwFL_x*swFL_x;
wFR_x=FwFR_x*swFR_x;
wRL_x=FwRL_x*swRL_x;
wRR_x=FwRR_x*swRR_x;

w_w_x=wFL_x+wFR_x+wRL_x+wRR_x;        %轮胎纵向力合力

%轮胎侧向力
swFL_y=zeros(6,1);
swFL_y(1:3,1)=[-sin(StFL) cos(StFL) 0]';
swFL_y(4:6,1)=cross(PFL,swFL_y(1:3,1));
 
swFR_y=zeros(6,1);
swFR_y(1:3,1)=[-sin(StFR) cos(StFR) 0]';
swFR_y(4:6,1)=cross(PFR,swFR_y(1:3,1));
 
swRL_y=zeros(6,1);
swRL_y(1:3,1)=[-sin(StRL) cos(StRL) 0]';
swRL_y(4:6,1)=cross(PRL,swRL_y(1:3,1));
 
swRR_y=zeros(6,1);
swRR_y(1:3,1)=[-sin(StRR) cos(StRR) 0]';
swRR_y(4:6,1)=cross(PRR,swRR_y(1:3,1));

wFL_y=FwFL_y*swFL_y;
wFR_y=FwFR_y*swFR_y;
wRL_y=FwRL_y*swRL_y;
wRR_y=FwRR_y*swRR_y;

w_w_y=wFL_y+wFR_y+wRL_y+wRR_y;         %轮胎侧向力合力

% 轮胎回正力矩
wMFL_z=MwFL_z*[0 0 0 0 0 1]';
wMFR_z=MwFR_z*[0 0 0 0 0 1]';
wMRL_z=MwRL_z*[0 0 0 0 0 1]';
wMRR_z=MwRR_z*[0 0 0 0 0 1]';

w_wM_z=wMFL_z+wMFR_z+wMRL_z+wMRR_z;     %轮胎回正力矩合力

% 侧向离心力
scen_y=zeros(6,1);
scen_y(1:3,1)=[0 1 0]';
scen_y(4:6,1)=cross(cg_i,scen_y(1:3,1));
wcen_y=-m*dx*dphi*scen_y;

% 纵向离心力
scen_x=zeros(6,1);
scen_x(1:3,1)=[1 0 0]';
scen_x(4:6,1)=cross(cg_i,scen_x(1:3,1));
wcen_x=m*dy*dphi*scen_x;

% 整车合力
w_xyz=wG+wFz+w_w_x+w_w_y+w_wM_z+wcen_y+wcen_x;   

% x轴方向加速度
Sx=[1 0 0 0 0 0]';
ddx=w_xyz'*Sx/m;

% y轴方向加速度
Sy=[0 1 0 0 0 0]';
ddy=w_xyz'*Sy/m;

% 横摆角加速度（横摆角）
S_z=[0 0 0 0 0 1]';
ddphi=w_xyz'*S_z/Izz;

%轮胎滚动角加速度
ddAFL=(TorFL_D+TorFL_B-r_eff*FwFL_x+MwFL_y)/Iw_roll;
ddAFR=(TorFR_D+TorFR_B-r_eff*FwFR_x+MwFR_y)/Iw_roll;
ddARL=(TorRL_D+TorRL_B-r_eff*FwRL_x+MwRL_y)/Iw_roll;
ddARR=(TorRR_D+TorRR_B-r_eff*FwRR_x+MwRR_y)/Iw_roll;

% XYZ全局坐标系下XY方向加速度
ddX=ddx*cos(phi)-dx*sin(phi)*dphi-ddy*sin(phi)-dy*cos(phi)*dphi;
ddY=ddx*sin(phi)+dx*cos(phi)*dphi+ddy*cos(phi)-dy*sin(phi)*dphi;

% du=[ddx,ddy,ddphi,ddAFL,ddAFR,ddARL,ddARR,ddX,ddY]';

== matlab function model_ref/车辆动力学模型/轮胎垂直载荷/车辆重力 ==
function [G_x,G_y,G_z]=G_Vehicle(u,phi)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 道路信息
Slope=u(1);           % 道路坡度
Shoulder=u(2);        % 道路路肩

%% 车辆横摆角
phi;
%% 整车重力
Mslope=[cos(Slope) 0 sin(Slope);0 1 0;-sin(Slope) 0 cos(Slope)];
% Mshoulder=[1 0 0; 0 cos(Shoulder) -sin(Shoulder); 0 sin(Shoulder) cos(Shoulder)];
% Mphi=[cos(phi) -sin(phi) 0; sin(phi) cos(phi) 0; 0 0 1];
MSS = Mslope;   % Mphi * Mshoulder*  
%MSS = Mshoulder * Mslope * Mphi;
%MSS=Mslope*Mshoulder*Mphi;

s_cg=zeros(3,1);
s_cg(1:3,1)=inv(MSS)*[0 0 1]';
w_cg=-m*g*s_cg;

%横摆角矩阵

G_x=0.2*w_cg(1);
G_y=w_cg(2);
G_z=w_cg(3);

== matlab function model_ref/车辆动力学模型/轮胎垂直载荷/轮胎垂直载荷 ==
function [Fz_FL,Fz_FR,Fz_RL,Fz_RR]=Vertical_Load(u)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 重力向量
w_cg=[0 0 u(3)]';

%% 悬架垂直力
% FsFL_z=u_1(4);
% FsFR_z=u_1(5);
% FsRL_z=u_1(6);
% FsRR_z=u_1(7);

%% 轮胎垂直力
% FwFL_z=u_1(8);
% FwFR_z=u_1(9);
% FwRL_z=u_1(10);
% FwRR_z=u_1(11);

%% 
PFL=[lf,TF/2,0]'; PFR=[lf,-TF/2,0]';    % 前轮接触点
PRL=[-lr,TR/2,0]'; PRR=[-lr,-TR/2,0]';  % 后轮接触点
cg_i=[0 0 hcg]';                        %质心位置

%% 车辆重力（考虑坡度和路肩）
wG=zeros(6,1);
wG(1:3,1)=w_cg;
wG(4:6,1)=cross(cg_i,wG(1:3,1));

%% 前轴
S_Fr=zeros(6,1);
S_Fr(4:6,1)=PFL-PFR;
S_Fr(1:3,1)=cross(PFL,S_Fr(4:6,1));
S_Fr=S_Fr/norm(S_Fr(4:6,1));

%% 后轴
S_Re=zeros(6,1);
S_Re(4:6,1)=PRL-PRR;
S_Re(1:3,1)=cross(PRL,S_Re(4:6,1));
S_Re=S_Re/norm(S_Re(4:6,1));

%% 左轴
S_Le=zeros(6,1);
S_Le(4:6,1)=PFL-PRL;
S_Le(1:3,1)=cross(PRL,S_Le(4:6,1));
S_Le=S_Le/norm(S_Le(4:6,1));

%% 右轴
S_Ri=zeros(6,1);
S_Ri(4:6,1)=PFR-PRR;
S_Ri(1:3,1)=cross(PRR,S_Ri(4:6,1));
S_Ri=S_Ri/norm(S_Ri(4:6,1));

%% 轮胎垂直载荷
s_zFL=zeros(6,1);
s_zFL(1:3,1)=[0 0 1]';
s_zFL(4:6,1)=cross(PFL,s_zFL(1:3,1));

s_zFR=zeros(6,1);
s_zFR(1:3,1)=[0 0 1]';
s_zFR(4:6,1)=cross(PFR,s_zFR(1:3,1));

s_zRL=zeros(6,1);
s_zRL(1:3,1)=[0 0 1]';
s_zRL(4:6,1)=cross(PRL,s_zRL(1:3,1));

s_zRR=zeros(6,1);
s_zRR(1:3,1)=[0 0 1]';
s_zRR(4:6,1)=cross(PRR,s_zRR(1:3,1));

A1=s_zFL'*S_Re; B1=s_zFR'*S_Re; C1=wG'*S_Re;
A2=s_zRL'*S_Fr; B2=s_zRR'*S_Fr; C2=wG'*S_Fr;
% A3=s_zFL'*S_Ri; B3=s_zRL'*S_Ri; C3=wG'*S_Ri;
% A4=s_zFR'*S_Le; B4=s_zRR'*S_Le; C4=wG'*S_Le;

Fz_FL=-C1/(A1+B1);
Fz_FR=Fz_FL;
Fz_RL=-C2/(A2+B2);
Fz_RR=Fz_RL;


% y=[Fz_FL Fz_FR Fz_RL Fz_RR]';

== matlab function model_ref/车辆动力学模型/车轮系统/车轮FL ==
function [sigma_x,alpha]=Wheel_sys(u)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 车辆状态
St_w=u(1);           % 轮胎转向角
w_w=u(2);            % 轮胎角速度
dx=u(3);             % 车辆纵向速度
dy=u(4);             % 车辆横向速度
dphi=u(5);           % 车辆横摆角速度

%% 纵向滑移率，横向滑移率，轮胎侧偏角
 % 轮胎纵向滑移率
A_B=max(abs(r_eff*w_w),abs(dx));
if A_B==0
    sigma_x=0;
else
    sigma_x=(r_eff*w_w-dx)/A_B;     
end

% 轮胎侧偏角    % 前轮
   if dx==0
      theta=0;
    else
       theta=atan((dy+lf*dphi)/dx);
   end

alpha=St_w-theta;      

% % 轮胎侧向滑移率 
% if alpha==0
%     sigma_y=0;
% else
%     sigma_y=dx/(r_eff*w_w)*tan(alpha);
% end
% y=sigma_x;

% y=[sigma_x  alpha];

== matlab function model_ref/车辆动力学模型/车轮系统/车轮FR ==
function [sigma_x,alpha]=Wheel_sys(u)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 车辆状态
St_w=u(1);           % 轮胎转向角
w_w=u(2);            % 轮胎角速度
dx=u(3);             % 车辆纵向速度
dy=u(4);             % 车辆横向速度
dphi=u(5);           % 车辆横摆角速度
%% 纵向滑移率，横向滑移率，轮胎侧偏角
 % 轮胎纵向滑移率
A_B=max(abs(r_eff*w_w),abs(dx));
if A_B==0
    sigma_x=0;
else
    sigma_x=(r_eff*w_w-dx)/A_B;     
end

% 轮胎侧偏角  % 前轮
      
   if dx==0
      theta=0;
    else
       theta=atan((dy+lf*dphi)/dx);
    end

alpha=St_w-theta;      

% % 轮胎侧向滑移率 
% if alpha==0
%     sigma_y=0;
% else
%     sigma_y=dx/(r_eff*w_w)*tan(alpha);
% end
% y=sigma_x;

% y=[sigma_x  alpha];

== matlab function model_ref/车辆动力学模型/车轮系统/车轮RL ==
function [sigma_x,alpha]=Wheel_sys(u)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 车辆状态
St_w=u(1);           % 轮胎转向角
w_w=u(2);            % 轮胎角速度
dx=u(3);             % 车辆纵向速度
dy=u(4);             % 车辆横向速度
dphi=u(5);           % 车辆横摆角速度

%% 纵向滑移率，横向滑移率，轮胎侧偏角
 % 轮胎纵向滑移率
A_B=max(abs(r_eff*w_w),abs(dx));
if A_B==0
    sigma_x=0;
else
    sigma_x=(r_eff*w_w-dx)/A_B;     
end

% 轮胎侧偏角     % 后轮
        if dx==0
            theta=0;
        else
             theta=atan((dy-lr*dphi)/dx);
        end
        
alpha=St_w-theta;      

% % 轮胎侧向滑移率 
% if alpha==0
%     sigma_y=0;
% else
%     sigma_y=dx/(r_eff*w_w)*tan(alpha);
% end
% y=sigma_x;

% y=[sigma_x  alpha];

== matlab function model_ref/车辆动力学模型/车轮系统/车轮RR ==
function [sigma_x,alpha]=Wheel_sys(u)
%% 车辆物理参数
g = 9.8;               % 重力加速度（m/s^2）

%整车参数
m = 1760;               % 整车质量（kg）
Izz = 2553.6;           % 整车Z轴转动惯量（kg*m^2）


TF = 1.6;               % 前轮距（m）
TR = 1.616;             % 后轮距（m）

L=2.8;                  % 轴距（m）
lf=1.159 ;              % 整车质心到前轴距离（m）
lr=L-lf;                % 整车质心到后轴距离（m）
hcg = 0.6283;           % 整车质心高度（m)

r_eff=0.314;            % 轮胎有效半径
mu_roll=0;              % 滚动阻力系数

Iw_roll=0.9;           % 车轮滚动惯量

%% 车辆状态
St_w=u(1);           % 轮胎转向角
w_w=u(2);            % 轮胎角速度
dx=u(3);             % 车辆纵向速度
dy=u(4);             % 车辆横向速度
dphi=u(5);           % 车辆横摆角速度

%% 纵向滑移率，横向滑移率，轮胎侧偏角
 % 轮胎纵向滑移率
A_B=max(abs(r_eff*w_w),abs(dx));
if A_B==0
    sigma_x=0;
else
    sigma_x=(r_eff*w_w-dx)/A_B;     
end

% 轮胎侧偏角   % 后轮
        if dx==0
            theta=0;
        else
             theta=atan((dy-lr*dphi)/dx);
        end

alpha=St_w-theta;      

% % 轮胎侧向滑移率 
% if alpha==0
%     sigma_y=0;
% else
%     sigma_y=dx/(r_eff*w_w)*tan(alpha);
% end
% y=sigma_x;

% y=[sigma_x  alpha];
